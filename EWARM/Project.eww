<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\Measuaring Frequency And Duty Cycle Using Input Capture.ewp</path>
  </project>
  <batchBuild />
</workspace>
